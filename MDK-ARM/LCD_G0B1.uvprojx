# Keil uVision project LCD_G0B1.uvprojx, settings and files
target LCD_G0B1 (6070000::V6.7::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCD_G0B1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ..\Core\Inc;..\Drivers\STM32G0xx_HAL_Driver\Inc;..\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32G0xx\Include;..\Drivers\CMSIS\Include;..\LCD;..\GC9D01;..\LCD\interfaces;.cmsis\include;RTE\_LCD_G0B1
  asm define: USE_HAL_DRIVER,STM32G0B1xx
  memory RVCT1: ROM 0x08000000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp progarm.cpp gpio.c dma.c spi.c usb_drd_fs.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group LCD
    ../GC9D01/: lcd_gc9d01.cpp lcd_gc9d01_config.h
    ../LCD/: Draw.cpp
software components: CMSIS:CORE 5.0.1
